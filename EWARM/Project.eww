<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\07_H743ZI_RTOS_Platform.ewp</path>
  </project>
  <batchBuild />
</workspace>
